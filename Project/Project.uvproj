# Keil uVision project Project.uvproj, settings and files
target Open1786 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0
  c include: ..\Libraries\LCP1768_StdPeriph_Driver\include;..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\User;..\User\DataProcess;..\User\Input;..\User\Output;..\User\UART;..\User\Config;..\User\GUI;..\User\CAN;..\User\hy_instance;..\User\systime;..\User\GW;..\User\langpuda;..\User\ShengYang
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ../Libraries/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/LCP1768_StdPeriph_Driver/source/: lpc17xx_gpio.c lpc17xx_uart.c lpc17xx_pinsel.c lpc17xx_clkpwr.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_wdt.c
  group User
    ../User/: main.c systen_delay.c debug_frmwrk.c hy_dbg.c hy_charge_task.c
  group Input
    ../User/Input/: hy_input.c
  group Output
    ../User/Output/: hy_output.c
  group UART
    ../User/UART/: UART.c
  group Config
    ../User/Config/: config.c
  group GUI
    ../User/GUI/: GUI.c GUI_driver.c GUI_page.c
  group CAN
    ../User/CAN/: hy_can.c
  group systime
    ../User/systime/: hy_systime.c
